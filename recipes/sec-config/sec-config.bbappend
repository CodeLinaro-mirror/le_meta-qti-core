do_configure[noexec] = "1"
